# Keil uVision project MASTER_prog.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: MASTER_prog
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MASTER_Config_Globale.c MASTER_Main.c FO_M1__Structures_COMMANDES_INFORMATIONS_CentraleDeCommande.h F0_M1.c F0_M1.h F0_M4.h
