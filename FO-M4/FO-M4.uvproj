# Keil uVision project FO-M4.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP3
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: FO-M4_Lib_Config_Globale_8051F020.c FO-M4_Lib_Divers.C FO-M4_Main.C c8051F020.h c8051F020_SFR16.h FO-M4_Lib_Config_Globale_8051F020.H FO-M4_Lib_Divers.H
